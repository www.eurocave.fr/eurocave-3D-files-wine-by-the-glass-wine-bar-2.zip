Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-03-02T15:32:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 02 15:32:18 2018 * Host: LT-SMN * Database: C:\Users\SEBAST~1\AppData\Local\Temp\{9519860A-BE1C-4F5C-8465-F4DC3838F07F}\ifc * Database version: 5507 * Database creation date: Fri Mar 02 15:32:18 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 02 15:32:18 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 02 15:32:18 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification - Nom du type: Ligne du Niveau; Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Contraintes - Base de l'élévation: Point de base du projet; Elévation: 0 m
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau; Nom de la famille: Niveau
Cotes - Hauteur de calcul: 0 m

# IfcBuildingElementProxy: Wine Bar 2.0, Wine bar 2.0 - UE:Wine Bar 2.0:236676
In: Niveau 0
Material: EUROCAVE - Acier poli, EUROCAVE - Nero, EUROCAVE - prise électrique, EUROCAVE - Vitre
Pset_BuildingElementProxyCommon - Reference: Wine Bar 2.0
Pset_ManufacturerTypeInformation - Manufacturer: EuroCave
Autre - Catégorie: Equipement spécialisé; Famille: Wine bar 2.0 - UE: Wine Bar 2.0; Famille et type: Wine bar 2.0 - UE: Wine Bar 2.0; ID du type: Wine bar 2.0 - UE: Wine Bar 2.0; Type: Wine bar 2.0 - UE: Wine Bar 2.0; Autres certificats produits: CEM EMC, International CB, JAPAN PSE, CHINA CCC; Certificat hygiène: Non applicable; Marquage CE: yes; Marquage ETL: yes; Nom de la famille: Wine bar 2.0 - UE
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.76623 m2; Volume: 0.0234393 m3
Graphismes - Conditions d'encastrement: yes
Phase de construction - Phase de création: Nouvelle construction
Données d'identification - Code de Révision: Fev-18; Commentaires du type: Solution pour le service du vin au verre; Description: Wine Bar 2.0; Durée de Garantie: 2 ans selon contrat; Fabricant: EuroCave; Modèle: WB 2.0; Nom du type: Wine Bar 2.0; URL: https://www.eurocavepro.fr/; URL catalogue: http://com.eurocave.fr/EuroCave-professional-catalogue/Catalogue-EuroCave-Professional-Francais.pdf
Electricité - Consommation d'énergie annuelle AEc***: 344 à 506 kWh/an; Cordons: CE - 230V 50Hz, CH - 230V 50Hz, UK - 230V 50Hz, USA - 115V 60Hz, Korea - 220V 60Hz, China - 220V 50Hz, Japan - 100V 50/60Hz, Australia - 240V 50Hz; Fréquence: 50 Hz; Intensité nominale: 0.65 A; Phase: 1; Puissance électrique: 80 W; Tension: 130 V; Type de Raccord Electrique: Prise électrique - Ne pas brancher sur une multiprise
Général - Hauteur hors tout: 0.491 m; Longueur hors tout: 0.315 m; Poids net à vide: 14; Profondeur hors tout: 0.268 m; Spécification du Fabricant: Respecter les conditions d'encastrements; Zone d'installation: Sur un bar ou encastrable sous conditions
Génie climatique - Classe Climatique: SN
Propriétés du modèle - Capacité (Nombre max de bouteilles): 2; Plage de réglage des températures: 8-16°C; Températures limites d'utilisation: 18-30°C
